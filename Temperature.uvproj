# Keil uVision project Temperature.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Sound
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: Sound.c
  group Sound Data
    ./: Data.c
  group Documentation
    ./: Abstract.txt
target MCB2130 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC2138 NXP (founded by Philips)
  cpu: as above
  output: Sound
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
